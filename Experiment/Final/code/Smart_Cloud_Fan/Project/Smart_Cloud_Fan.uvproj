# Keil uVision project Smart_Cloud_Fan.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Smart_Cloud_Fan +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Api;..\Public;..\User
  group Api
    ../Api/: matrix_key.c display.c pwm.c step_motor.c DS18B20.c infrared.c wifi.c
  group Public
    ../Public/: delay.c timer.c global.c function.c
  group User
    ../User/: main.c
