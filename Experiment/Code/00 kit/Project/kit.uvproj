# Keil uVision project kit.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: kit +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\Api;..\Public;..\User
  group Api
    ../Api/: led_running.c button.c matrix_key.c display.c lcd1602.c pwm.c dc_motor.c step_motor.c DS18B20.c infrared.c wifi.c
  group Public
    ../Public/: delay.c timer.c global.c uart.c
  group User
    ../User/: main.c
