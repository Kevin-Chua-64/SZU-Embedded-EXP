# Keil uVision project lcd1602.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: lcd1602 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\App\lcd1602;.\Public
  group App
    ./App/lcd1602/: lcd1602.c
  group Public
    ./Public/: public.c
  group User
    ./User/: main.c
