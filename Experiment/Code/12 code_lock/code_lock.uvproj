# Keil uVision project code_lock.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80/87C52 Intel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: code_lock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\12 code_lock
  group Source Group 1
    ./: lcd1602.c main.c matrix_key.c delay.c
